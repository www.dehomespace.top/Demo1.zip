FUNCTION_BLOCK POU_1
VAR_INPUT
END_VAR
VAR_OUTPUT
END_VAR
VAR
END_VAR

// NETWORK 1

END_FUNCTION_BLOCK
